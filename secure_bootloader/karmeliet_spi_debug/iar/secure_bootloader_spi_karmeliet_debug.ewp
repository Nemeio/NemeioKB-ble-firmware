# IAR project secure_bootloader_spi_karmeliet_debug.ewp, settings and files
configuration nrf52832_xxaa_mbr (ARM)
  General.OGChipSelectEditMenu: nRF52832-xxAA NordicSemi nRF52832-xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: BOARD_PCA10040; CONFIG_GPIO_AS_PINRESET; DEBUG_NRF; FLOAT_ABI_HARD; MBR_PRESENT; NRF52; NRF52832_XXAA; NRF52_PAN_74; NRF_DFU_DEBUG_VERSION; NRF_DFU_SETTINGS_VERSION=2; SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION; uECC_ENABLE_VLI_API=0; uECC_OPTIMIZATION_LEVEL=3; uECC_SQUARE_FUNC=0; uECC_SUPPORT_COMPRESSED_POINT=0; uECC_VLI_NATIVE_LITTLE_ENDIAN=1; NEMEIO_BOOTLOADER
  ICCARM.CCIncludePath2: ..\..\config; ..\..\..\nRF5_SDK\components\boards; ..\..\..\nRF5_SDK\components\drivers_nrf\nrf_soc_nosd; ..\..\..\nRF5_SDK\components\libraries\atomic; ..\..\..\nRF5_SDK\components\libraries\balloc; ..\..\..\nRF5_SDK\components\libraries\bootloader; ..\..\..\nRF5_SDK\components\libraries\bootloader\dfu; ..\..\..\nRF5_SDK\components\libraries\bootloader\serial_dfu; ..\..\..\nRF5_SDK\components\libraries\crc32; ..\..\..\nRF5_SDK\components\libraries\crypto; ..\..\..\nRF5_SDK\components\libraries\crypto\backend\cc310; ..\..\..\nRF5_SDK\components\libraries\crypto\backend\cc310_bl; ..\..\..\nRF5_SDK\components\libraries\crypto\backend\cifra; ..\..\..\nRF5_SDK\components\libraries\crypto\backend\mbedtls; ..\..\..\nRF5_SDK\components\libraries\crypto\backend\micro_ecc; ..\..\..\nRF5_SDK\components\libraries\crypto\backend\nrf_hw; ..\..\..\nRF5_SDK\components\libraries\crypto\backend\nrf_sw; ..\..\..\nRF5_SDK\components\libraries\crypto\backend\oberon; ..\..\..\nRF5_SDK\components\libraries\crypto\backend\optiga; ..\..\..\nRF5_SDK\components\libraries\delay; ..\..\..\nRF5_SDK\components\libraries\experimental_section_vars; ..\..\..\nRF5_SDK\components\libraries\fifo; ..\..\..\nRF5_SDK\components\libraries\fstorage; ..\..\..\nRF5_SDK\components\libraries\log; ..\..\..\nRF5_SDK\components\libraries\log\src; ..\..\..\nRF5_SDK\components\libraries\mem_manager; ..\..\..\nRF5_SDK\components\libraries\memobj; ..\..\..\nRF5_SDK\components\libraries\queue; ..\..\..\nRF5_SDK\components\libraries\ringbuf; ..\..\..\nRF5_SDK\components\libraries\scheduler; ..\..\..\nRF5_SDK\components\libraries\sha256; ..\..\..\nRF5_SDK\components\libraries\slip; ..\..\..\nRF5_SDK\components\libraries\stack_info; ..\..\..\nRF5_SDK\components\libraries\strerror; ..\..\..\nRF5_SDK\components\libraries\util; ..\..\..\nRF5_SDK\components\softdevice\mbr\nrf52832\headers; ..\..\..\nRF5_SDK\components\toolchain\cmsis\include; ..\..; ..\..\..\nRF5_SDK\external\fprintf; ..\..\..\nRF5_SDK\external\micro-ecc\micro-ecc; ..\..\..\nRF5_SDK\external\nano-pb; ..\..\..\nRF5_SDK\external\nrf_oberon; ..\..\..\nRF5_SDK\external\nrf_oberon\include; ..\..\..\nRF5_SDK\external\segger_rtt; ..\..\..\nRF5_SDK\integration\nrfx; ..\..\..\nRF5_SDK\integration\nrfx\legacy; ..\..\..\nRF5_SDK\modules\nrfx; ..\..\..\nRF5_SDK\modules\nrfx\drivers\include; ..\..\..\nRF5_SDK\modules\nrfx\hal; ..\..\..\nRF5_SDK\modules\nrfx\mdk; ..\config; ..\..\..\SPI_Protocol_Common; ..\..\Libraries\slip_custom; ..\..\Libraries\SPI_DFU
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD_PCA10040; CONFIG_GPIO_AS_PINRESET; DEBUG_NRF; FLOAT_ABI_HARD; MBR_PRESENT; NRF52; NRF52832_XXAA; NRF52_PAN_74; NRF_DFU_DEBUG_VERSION; NRF_DFU_SETTINGS_VERSION=2; SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION; uECC_ENABLE_VLI_API=0; uECC_OPTIMIZATION_LEVEL=3; uECC_SQUARE_FUNC=0; uECC_SUPPORT_COMPRESSED_POINT=0; uECC_VLI_NATIVE_LITTLE_ENDIAN=1
  AARM.AUserIncludes: ..\..\config; ..\..\..\nRF5_SDK\components\boards; ..\..\..\nRF5_SDK\components\drivers_nrf\nrf_soc_nosd; ..\..\..\nRF5_SDK\components\libraries\atomic; ..\..\..\nRF5_SDK\components\libraries\balloc; ..\..\..\nRF5_SDK\components\libraries\bootloader; ..\..\..\nRF5_SDK\components\libraries\bootloader\dfu; ..\..\..\nRF5_SDK\components\libraries\bootloader\serial_dfu; ..\..\..\nRF5_SDK\components\libraries\crc32; ..\..\..\nRF5_SDK\components\libraries\crypto; ..\..\..\nRF5_SDK\components\libraries\crypto\backend\cc310; ..\..\..\nRF5_SDK\components\libraries\crypto\backend\cc310_bl; ..\..\..\nRF5_SDK\components\libraries\crypto\backend\cifra; ..\..\..\nRF5_SDK\components\libraries\crypto\backend\mbedtls; ..\..\..\nRF5_SDK\components\libraries\crypto\backend\micro_ecc; ..\..\..\nRF5_SDK\components\libraries\crypto\backend\nrf_hw; ..\..\..\nRF5_SDK\components\libraries\crypto\backend\nrf_sw; ..\..\..\nRF5_SDK\components\libraries\crypto\backend\oberon; ..\..\..\nRF5_SDK\components\libraries\crypto\backend\optiga; ..\..\..\nRF5_SDK\components\libraries\delay; ..\..\..\nRF5_SDK\components\libraries\experimental_section_vars; ..\..\..\nRF5_SDK\components\libraries\fstorage; ..\..\..\nRF5_SDK\components\libraries\log; ..\..\..\nRF5_SDK\components\libraries\log\src; ..\..\..\nRF5_SDK\components\libraries\mem_manager; ..\..\..\nRF5_SDK\components\libraries\memobj; ..\..\..\nRF5_SDK\components\libraries\queue; ..\..\..\nRF5_SDK\components\libraries\ringbuf; ..\..\..\nRF5_SDK\components\libraries\scheduler; ..\..\..\nRF5_SDK\components\libraries\sha256; ..\..\..\nRF5_SDK\components\libraries\slip; ..\..\..\nRF5_SDK\components\libraries\stack_info; ..\..\..\nRF5_SDK\components\libraries\strerror; ..\..\..\nRF5_SDK\components\libraries\util; ..\..\..\nRF5_SDK\components\softdevice\mbr\nrf52832\headers; ..\..\..\nRF5_SDK\components\toolchain\cmsis\include; ..\..; ..\..\..\nRF5_SDK\external\fprintf; ..\..\..\nRF5_SDK\external\micro-ecc\micro-ecc; ..\..\..\nRF5_SDK\external\nano-pb; ..\..\..\nRF5_SDK\external\nrf_oberon; ..\..\..\nRF5_SDK\external\nrf_oberon\include; ..\..\..\nRF5_SDK\external\segger_rtt; ..\..\..\nRF5_SDK\integration\nrfx; ..\..\..\nRF5_SDK\integration\nrfx\legacy; ..\..\..\nRF5_SDK\modules\nrfx; ..\..\..\nRF5_SDK\modules\nrfx\drivers\include; ..\..\..\nRF5_SDK\modules\nrfx\hal; ..\..\..\nRF5_SDK\modules\nrfx\mdk; ..\config
  OBJCOPY.OOCOutputFile: secure_bootloader_uart_mbr_pca10040_debug.hex
  ILINK.IlinkOutputFile: secure_bootloader_uart_mbr_pca10040_debug.out
  ILINK.IlinkIcfFile: secure_bootloader_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../: dfu_public_key.c main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../nRF5_SDK/components/boards/: boards.c
  group Libraries/slip_custom
    ../../Libraries/slip_custom/: slip_custom.c slip_custom.h
  group Libraries/SPI_DFU
    ../../Libraries/SPI_DFU/: dfu_transport_spi.c dfu_transport_spi.h spi_protocol_dfu_data.c spi_protocol_dfu_data.h
    ../../../SPI_Protocol_Common/: spi_protocol_dfu_cmd.c spi_protocol_dfu_cmd.h
  group nano-pb
    ../../../nRF5_SDK/external/nano-pb/: pb_common.c pb_decode.c
  group None
    ../../../nRF5_SDK/modules/nrfx/mdk/: iar_startup_nrf52.s system_nrf52.c
  group nRF_Bootloader
    ../../../nRF5_SDK/components/libraries/bootloader/: nrf_bootloader_app_start.c nrf_bootloader_app_start_final.c nrf_bootloader_dfu_timers.c nrf_bootloader_fw_activation.c nrf_bootloader_info.c nrf_bootloader_wdt.c
    ../../Libraries/bootloader_custom/: nrf_bootloader_custom.c
  group nRF_Crypto
    ../../../nRF5_SDK/components/libraries/crypto/: nrf_crypto_ecc.c nrf_crypto_ecdsa.c nrf_crypto_hash.c nrf_crypto_init.c nrf_crypto_shared.c
  group nRF_Crypto backend nRF sw
    ../../../nRF5_SDK/components/libraries/crypto/backend/nrf_sw/: nrf_sw_backend_hash.c
  group nRF_Crypto backend Oberon
    ../../../nRF5_SDK/components/libraries/crypto/backend/oberon/: oberon_backend_chacha_poly_aead.c oberon_backend_ecc.c oberon_backend_ecdh.c oberon_backend_ecdsa.c oberon_backend_eddsa.c oberon_backend_hash.c oberon_backend_hmac.c
  group nRF_Crypto backend uECC
    ../../../nRF5_SDK/components/libraries/crypto/backend/micro_ecc/: micro_ecc_backend_ecc.c micro_ecc_backend_ecdh.c micro_ecc_backend_ecdsa.c
  group nRF_DFU
    ../../../nRF5_SDK/components/libraries/bootloader/dfu/: dfu-cc.pb.c nrf_dfu.c nrf_dfu_flash.c nrf_dfu_handling_error.c nrf_dfu_mbr.c nrf_dfu_req_handler.c nrf_dfu_settings.c nrf_dfu_transport.c nrf_dfu_utils.c nrf_dfu_ver_validation.c
    ../../Libraries/bootloader_custom/dfu/: nrf_dfu_validation_custom.c
  group nRF_Drivers
    ../../../nRF5_SDK/integration/nrfx/legacy/: nrf_drv_spis.c nrf_drv_uart.c
    ../../../nRF5_SDK/components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
    ../../../nRF5_SDK/modules/nrfx/hal/: nrf_nvmc.c
    ../../../nRF5_SDK/modules/nrfx/soc/: nrfx_atomic.c
    ../../../nRF5_SDK/modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ../../../nRF5_SDK/modules/nrfx/drivers/src/: nrfx_spis.c nrfx_uart.c nrfx_uarte.c
  group nRF_Libraries
    ../../../nRF5_SDK/components/libraries/util/: app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../nRF5_SDK/components/libraries/fifo/: app_fifo.c
    ../../../nRF5_SDK/components/libraries/scheduler/: app_scheduler.c
    ../../../nRF5_SDK/components/libraries/crc32/: crc32.c
    ../../../nRF5_SDK/components/libraries/mem_manager/: mem_manager.c
    ../../../nRF5_SDK/components/libraries/atomic/: nrf_atomic.c
    ../../../nRF5_SDK/components/libraries/balloc/: nrf_balloc.c
    ../../../nRF5_SDK/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../nRF5_SDK/components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_nvmc.c
    ../../../nRF5_SDK/components/libraries/memobj/: nrf_memobj.c
    ../../../nRF5_SDK/components/libraries/queue/: nrf_queue.c
    ../../../nRF5_SDK/components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../nRF5_SDK/components/libraries/strerror/: nrf_strerror.c
    ../../../nRF5_SDK/components/libraries/sha256/: sha256.c
    ../../../nRF5_SDK/components/libraries/slip/: slip.c
  group nRF_Log
    ../../../nRF5_SDK/components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_micro-ecc
    ../../../nRF5_SDK/external/micro-ecc/nrf52hf_iar/armgcc/: micro_ecc_lib_nrf52.a
  group nRF_Oberon_Crypto
    ../../../nRF5_SDK/external/nrf_oberon/lib/cortex-m4/hard-float/short-wchar/: liboberon_2.0.7.a
  group nRF_Segger_RTT
    ../../../nRF5_SDK/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_IAR.c
  group nRF_Serial_DFU
    ../../../nRF5_SDK/components/libraries/bootloader/serial_dfu/: nrf_dfu_serial.c
  group SPI_Protocol
    ../../../SPI_Protocol_Common/: spi_config.h spi_protocol.c spi_protocol.h spi_protocol_common_actions.h spi_protocol_tx.c spi_protocol_tx.h
    ../../Libraries/SPI_DFU/: spi_protocol_bootloader_actions.h
