<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\LDLC_Keyboard\s132\iar\LDLC_BLE_HID_Keyboard_LDLC_Keyboard_s132.ewp</path>
  </project> <batchBuild/>
</workspace>