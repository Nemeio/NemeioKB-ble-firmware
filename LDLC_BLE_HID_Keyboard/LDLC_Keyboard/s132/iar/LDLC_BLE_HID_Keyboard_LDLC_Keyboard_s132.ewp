# IAR project LDLC_BLE_HID_Keyboard_LDLC_Keyboard_s132.ewp, settings and files
configuration nrf52832_xxaa (ARM)
  General.OGChipSelectEditMenu: nRF52832-xxAA NordicSemi nRF52832-xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: BOARD_PCA10040; CONFIG_GPIO_AS_PINRESET; NRF52; NRF52832_XXAA; NRF52_PAN_12; NRF52_PAN_15; NRF52_PAN_20; NRF52_PAN_31; NRF52_PAN_36; NRF52_PAN_51; NRF52_PAN_54; NRF52_PAN_55; NRF52_PAN_58; NRF52_PAN_64; NRF52_PAN_74; NRF_SD_BLE_API_VERSION=6; S132; SOFTDEVICE_PRESENT; SWI_DISABLE0; ENABLE_TRACE; ENABLE_SWO; ENABLE_DEBUG_LOG_SUPPORT; FW_VERSION_DEF="0.2.43.20001"
  ICCARM.CCIncludePath2: ..\..\..\..\nRF5_SDK\components; ..\..\..\..\nRF5_SDK\components\ble\ble_dtm; ..\..\..\..\nRF5_SDK\components\ble\ble_racp; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_ancs_c; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_ans_c; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_bas; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_bas_c; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_cscs; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_cts_c; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_dfu; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_dis; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_gls; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_hids; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_hrs; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_hrs_c; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_hts; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_ias; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_ias_c; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_lbs; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_lbs_c; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_lls; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_rscs; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_rscs_c; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_tps; ..\..\..\src\Libraries\ble_srv_common_custom; ..\..\..\..\nRF5_SDK\components\ble\common; ..\..\..\..\nRF5_SDK\components\ble\nrf_ble_gatt; ..\..\..\..\nRF5_SDK\components\ble\nrf_ble_qwr; ..\..\..\..\nRF5_SDK\components\ble\peer_manager; ..\..\..\..\nRF5_SDK\components\boards; ..\..\..\..\nRF5_SDK\components\device; ..\..\..\..\nRF5_SDK\components\drivers_nrf\clock; ..\..\..\..\nRF5_SDK\components\drivers_nrf\common; ..\..\..\..\nRF5_SDK\components\drivers_nrf\comp; ..\..\..\..\nRF5_SDK\components\libraries\delay; ..\..\..\..\nRF5_SDK\components\drivers_nrf\gpiote; ..\..\..\..\nRF5_SDK\components\drivers_nrf\hal; ..\..\..\..\nRF5_SDK\components\drivers_nrf\i2s; ..\..\..\..\nRF5_SDK\components\drivers_nrf\lpcomp; ..\..\..\..\nRF5_SDK\components\libraries\mutex; ..\..\..\..\nRF5_SDK\components\drivers_nrf\pdm; ..\..\..\..\nRF5_SDK\components\drivers_nrf\power; ..\..\..\..\nRF5_SDK\components\drivers_nrf\ppi; ..\..\..\..\nRF5_SDK\components\drivers_nrf\pwm; ..\..\..\..\nRF5_SDK\components\drivers_nrf\qdec; ..\..\..\..\nRF5_SDK\components\drivers_nrf\rng; ..\..\..\..\nRF5_SDK\components\drivers_nrf\rtc; ..\..\..\..\nRF5_SDK\components\drivers_nrf\saadc; ..\..\..\..\nRF5_SDK\components\drivers_nrf\spi_master; ..\..\..\..\nRF5_SDK\components\drivers_nrf\spi_slave; ..\..\..\..\nRF5_SDK\components\drivers_nrf\swi; ..\..\..\..\nRF5_SDK\components\drivers_nrf\timer; ..\..\..\..\nRF5_SDK\components\drivers_nrf\twi_master; ..\..\..\..\nRF5_SDK\components\drivers_nrf\twis_slave; ..\..\..\..\nRF5_SDK\components\drivers_nrf\uart; ..\..\..\..\nRF5_SDK\components\drivers_nrf\usbd; ..\..\..\..\nRF5_SDK\components\drivers_nrf\wdt; ..\..\..\..\nRF5_SDK\components\libraries\atomic; ..\..\..\..\nRF5_SDK\components\libraries\atomic_fifo; ..\..\..\..\nRF5_SDK\components\libraries\atomic_flags; ..\..\..\..\nRF5_SDK\components\libraries\balloc; ..\..\..\..\nRF5_SDK\components\libraries\bootloader; ..\..\..\..\nRF5_SDK\components\libraries\bsp; ..\..\..\..\nRF5_SDK\components\libraries\button; ..\..\..\..\nRF5_SDK\components\libraries\crc16; ..\..\..\..\nRF5_SDK\components\libraries\crc32; ..\..\..\..\nRF5_SDK\components\libraries\crypto; ..\..\..\..\nRF5_SDK\components\libraries\crypto\backend\cc310; ..\..\..\..\nRF5_SDK\components\libraries\crypto\backend\cc310_bl; ..\..\..\..\nRF5_SDK\components\libraries\crypto\backend\cifra; ..\..\..\..\nRF5_SDK\components\libraries\crypto\backend\mbedtls; ..\..\..\..\nRF5_SDK\components\libraries\crypto\backend\micro_ecc; ..\..\..\..\nRF5_SDK\components\libraries\crypto\backend\nrf_hw; ..\..\..\..\nRF5_SDK\components\libraries\crypto\backend\nrf_sw; ..\..\..\..\nRF5_SDK\components\libraries\crypto\backend\oberon; ..\..\..\..\nRF5_SDK\components\libraries\crypto\backend\optiga; ..\..\..\..\nRF5_SDK\components\libraries\csense; ..\..\..\..\nRF5_SDK\components\libraries\csense_drv; ..\..\..\..\nRF5_SDK\components\libraries\ecc; ..\..\..\..\nRF5_SDK\components\libraries\experimental_section_vars; ..\..\..\..\nRF5_SDK\components\libraries\fifo; ..\..\..\..\nRF5_SDK\components\libraries\fds; ..\..\..\..\nRF5_SDK\components\libraries\fstorage; ..\..\..\..\nRF5_SDK\components\libraries\gpiote; ..\..\..\..\nRF5_SDK\components\libraries\hardfault; ..\..\..\..\nRF5_SDK\components\libraries\hci; ..\..\..\..\nRF5_SDK\components\libraries\led_softblink; ..\..\..\..\nRF5_SDK\components\libraries\log; ..\..\..\..\nRF5_SDK\components\libraries\log\src; ..\..\..\..\nRF5_SDK\components\libraries\low_power_pwm; ..\..\..\..\nRF5_SDK\components\libraries\mem_manager; ..\..\..\..\nRF5_SDK\components\libraries\memobj; ..\..\..\..\nRF5_SDK\components\libraries\pwm; ..\..\..\..\nRF5_SDK\components\libraries\pwr_mgmt; ..\..\..\..\nRF5_SDK\components\libraries\queue; ..\..\..\..\nRF5_SDK\components\libraries\scheduler; ..\..\..\..\nRF5_SDK\components\libraries\sensorsim; ..\..\..\..\nRF5_SDK\components\libraries\slip; ..\..\..\..\nRF5_SDK\components\libraries\stack_info; ..\..\..\..\nRF5_SDK\components\libraries\strerror; ..\..\..\..\nRF5_SDK\components\libraries\ringbuf; ..\..\..\..\nRF5_SDK\components\libraries\timer; ..\..\..\..\nRF5_SDK\components\libraries\twi; ..\..\..\..\nRF5_SDK\components\libraries\uart; ..\..\..\..\nRF5_SDK\components\libraries\usbd; ..\..\..\..\nRF5_SDK\components\libraries\usbd\class\audio; ..\..\..\..\nRF5_SDK\components\libraries\usbd\class\cdc; ..\..\..\..\nRF5_SDK\components\libraries\usbd\class\cdc\acm; ..\..\..\..\nRF5_SDK\components\libraries\usbd\class\hid; ..\..\..\..\nRF5_SDK\components\libraries\usbd\class\hid\generic; ..\..\..\..\nRF5_SDK\components\libraries\usbd\class\hid\kbd; ..\..\..\..\nRF5_SDK\components\libraries\usbd\class\hid\mouse; ..\..\..\..\nRF5_SDK\components\libraries\usbd\class\msc; ..\..\..\..\nRF5_SDK\components\libraries\usbd\config; ..\..\..\..\nRF5_SDK\components\libraries\util; ..\..\..\..\nRF5_SDK\components\softdevice\common; ..\..\..\..\nRF5_SDK\components\softdevice\s132\headers; ..\..\..\..\nRF5_SDK\components\softdevice\s132\headers\nrf52; ..\..\..\..\nRF5_SDK\components\toolchain; ..\..\..\..\nRF5_SDK\components\toolchain\cmsis\include; ..\..\..\..\nRF5_SDK\external\mbedtls\include; ..\..\..\..\nRF5_SDK\external\nrf_oberon; ..\..\..\..\nRF5_SDK\external\nrf_oberon\include; ..\..\..\..\nRF5_SDK\external\segger_rtt; ..\..\..\..\nRF5_SDK\external\segger_rtt; ..\..\..\src\SPI_Protocol; ..\..\..\src\BLE_HID; ..\..\..\src\BLE_NUS; ..\..\..\src\BLE_NUS\ble_nus_custom; ..\config; ..\..\..\src\Libraries\Hibernation; ..\..\..\src\Libraries; ..\..\..\src\Libraries\DeviceList; ..\..\..\src\Libraries\ble_advertising_custom; ..\..\..\src\Libraries\LESC; ..\..\..\src\Libraries\DeviceName; ..\..\..\src\Libraries\BLEEvent; ..\..\..\..\nRF5_SDK\integration\nrfx; ..\..\..\..\nRF5_SDK\integration\nrfx\legacy; ..\..\..\..\nRF5_SDK\modules\nrfx; ..\..\..\..\nRF5_SDK\modules\nrfx\drivers\include; ..\..\..\..\nRF5_SDK\modules\nrfx\hal; ..\..\..\..\nRF5_SDK\modules\nrfx\mdk; ..\..\..\..\nRF5_SDK\components\ble\ble_link_ctx_manager; ..\..\..\..\SPI_Protocol_Common; ..\..\..\src\Libraries\FactoryReset
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: BLE_STACK_SUPPORT_REQD; BOARD_PCA10040; CONFIG_GPIO_AS_PINRESET; NRF52; NRF52832_XXAA; NRF52_PAN_12; NRF52_PAN_15; NRF52_PAN_20; NRF52_PAN_31; NRF52_PAN_36; NRF52_PAN_51; NRF52_PAN_54; NRF52_PAN_55; NRF52_PAN_58; NRF52_PAN_64; NRF52_PAN_74; NRF_SD_BLE_API_VERSION=4; S132; SOFTDEVICE_PRESENT; SWI_DISABLE0
  AARM.AUserIncludes: ..\..\..\..\nRF5_SDK\components; ..\..\..\..\nRF5_SDK\components\ble\ble_advertising; ..\..\..\..\nRF5_SDK\components\ble\ble_dtm; ..\..\..\..\nRF5_SDK\components\ble\ble_racp; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_ancs_c; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_ans_c; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_bas; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_bas_c; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_cscs; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_cts_c; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_dfu; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_dis; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_gls; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_hids; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_hrs; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_hrs_c; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_hts; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_ias; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_ias_c; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_lbs; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_lbs_c; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_lls; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_nus; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_nus_c; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_rscs; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_rscs_c; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_tps; ..\..\..\..\nRF5_SDK\components\ble\common; ..\..\..\..\nRF5_SDK\components\ble\nrf_ble_gatt; ..\..\..\..\nRF5_SDK\components\ble\nrf_ble_qwr; ..\..\..\..\nRF5_SDK\components\ble\peer_manager; ..\..\..\..\nRF5_SDK\components\boards; ..\..\..\..\nRF5_SDK\components\device; ..\..\..\..\nRF5_SDK\components\drivers_nrf\clock; ..\..\..\..\nRF5_SDK\components\drivers_nrf\common; ..\..\..\..\nRF5_SDK\components\drivers_nrf\comp; ..\..\..\..\nRF5_SDK\components\drivers_nrf\delay; ..\..\..\..\nRF5_SDK\components\drivers_nrf\gpiote; ..\..\..\..\nRF5_SDK\components\drivers_nrf\hal; ..\..\..\..\nRF5_SDK\components\drivers_nrf\i2s; ..\..\..\..\nRF5_SDK\components\drivers_nrf\lpcomp; ..\..\..\..\nRF5_SDK\components\drivers_nrf\pdm; ..\..\..\..\nRF5_SDK\components\drivers_nrf\power; ..\..\..\..\nRF5_SDK\components\drivers_nrf\ppi; ..\..\..\..\nRF5_SDK\components\drivers_nrf\pwm; ..\..\..\..\nRF5_SDK\components\drivers_nrf\qdec; ..\..\..\..\nRF5_SDK\components\drivers_nrf\rng; ..\..\..\..\nRF5_SDK\components\drivers_nrf\rtc; ..\..\..\..\nRF5_SDK\components\drivers_nrf\saadc; ..\..\..\..\nRF5_SDK\components\drivers_nrf\spi_master; ..\..\..\..\nRF5_SDK\components\drivers_nrf\spi_slave; ..\..\..\..\nRF5_SDK\components\drivers_nrf\swi; ..\..\..\..\nRF5_SDK\components\drivers_nrf\timer; ..\..\..\..\nRF5_SDK\components\drivers_nrf\twi_master; ..\..\..\..\nRF5_SDK\components\drivers_nrf\twis_slave; ..\..\..\..\nRF5_SDK\components\drivers_nrf\uart; ..\..\..\..\nRF5_SDK\components\drivers_nrf\usbd; ..\..\..\..\nRF5_SDK\components\drivers_nrf\wdt; ..\..\..\..\nRF5_SDK\components\libraries\bsp; ..\..\..\..\nRF5_SDK\components\libraries\button; ..\..\..\..\nRF5_SDK\components\libraries\crc16; ..\..\..\..\nRF5_SDK\components\libraries\crc32; ..\..\..\..\nRF5_SDK\components\libraries\csense; ..\..\..\..\nRF5_SDK\components\libraries\csense_drv; ..\..\..\..\nRF5_SDK\components\libraries\ecc; ..\..\..\..\nRF5_SDK\components\libraries\experimental_section_vars; ..\..\..\..\nRF5_SDK\components\libraries\fds; ..\..\..\..\nRF5_SDK\components\libraries\fstorage; ..\..\..\..\nRF5_SDK\components\libraries\gpiote; ..\..\..\..\nRF5_SDK\components\libraries\hardfault; ..\..\..\..\nRF5_SDK\components\libraries\hci; ..\..\..\..\nRF5_SDK\components\libraries\led_softblink; ..\..\..\..\nRF5_SDK\components\libraries\log; ..\..\..\..\nRF5_SDK\components\libraries\log\src; ..\..\..\..\nRF5_SDK\components\libraries\low_power_pwm; ..\..\..\..\nRF5_SDK\components\libraries\mem_manager; ..\..\..\..\nRF5_SDK\components\libraries\pwm; ..\..\..\..\nRF5_SDK\components\libraries\queue; ..\..\..\..\nRF5_SDK\components\libraries\scheduler; ..\..\..\..\nRF5_SDK\components\libraries\sensorsim; ..\..\..\..\nRF5_SDK\components\libraries\slip; ..\..\..\..\nRF5_SDK\components\libraries\strerror; ..\..\..\..\nRF5_SDK\components\libraries\timer; ..\..\..\..\nRF5_SDK\components\libraries\twi; ..\..\..\..\nRF5_SDK\components\libraries\uart; ..\..\..\..\nRF5_SDK\components\libraries\usbd; ..\..\..\..\nRF5_SDK\components\libraries\usbd\class\audio; ..\..\..\..\nRF5_SDK\components\libraries\usbd\class\cdc; ..\..\..\..\nRF5_SDK\components\libraries\usbd\class\cdc\acm; ..\..\..\..\nRF5_SDK\components\libraries\usbd\class\hid; ..\..\..\..\nRF5_SDK\components\libraries\usbd\class\hid\generic; ..\..\..\..\nRF5_SDK\components\libraries\usbd\class\hid\kbd; ..\..\..\..\nRF5_SDK\components\libraries\usbd\class\hid\mouse; ..\..\..\..\nRF5_SDK\components\libraries\usbd\class\msc; ..\..\..\..\nRF5_SDK\components\libraries\usbd\config; ..\..\..\..\nRF5_SDK\components\libraries\util; ..\..\..\..\nRF5_SDK\components\softdevice\common\softdevice_handler; ..\..\..\..\nRF5_SDK\components\softdevice\s132\headers; ..\..\..\..\nRF5_SDK\components\softdevice\s132\headers\nrf52; ..\..\..\..\nRF5_SDK\components\toolchain; ..\..\..\..\nRF5_SDK\components\toolchain\cmsis\include; ..\..\..\..\nRF5_SDK\external\segger_rtt; ..\config
  OBJCOPY.OOCOutputFile: LDLC_BLE_HID_Keyboard_LDLC_Keyboard_s132.hex
  ILINK.IlinkOutputFile: LDLC_BLE_HID_Keyboard_LDLC_Keyboard_s132.out
  ILINK.IlinkIcfFile: LDLC_BLE_HID_Keyboard_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../../src/Libraries/: swo_log.c
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group Application/BLE_HID
    ../../../src/BLE_HID/: app_ble_hid.c app_ble_hid.h
  group Application/BLE_NUS
    ../../../src/BLE_NUS/: app_ble_nus.c app_ble_nus.h
  group Application/BLE_NUS/ble_nus_custom
    ../../../src/BLE_NUS/ble_nus_custom/: ble_nus_custom.c ble_nus_custom.h
  group Application/Libraries
    ../../../src/Libraries/: app_trace.c app_trace.h application_defs.h ble_management.c ble_management.h swo_log.h
  group Application/Libraries/ble_advertising_custom
    ../../../src/Libraries/ble_advertising_custom/: ble_advertising_custom.c ble_advertising_custom.h
  group Application/Libraries/ble_srv_common_custom
    ../../../src/Libraries/BLEEvent/: ble_event_notification.c ble_event_notification.h
  group Application/Libraries/BLEEvent
    ../../../src/Libraries/ble_srv_common_custom/: ble_srv_common.c ble_srv_common.h
  group Application/Libraries/DeviceList
    ../../../src/Libraries/DeviceList/: device_list.c device_list.h
  group Application/Libraries/DeviceName
    ../../../src/Libraries/DeviceName/: device_name.c device_name.h
  group Application/Libraries/FactoryReset
    ../../../src/Libraries/FactoryReset/: factory_reset.c factory_reset.h
  group Application/Libraries/LESC
    ../../../src/Libraries/LESC/: app_lesc.c app_lesc.h
  group Application/SPI_Protocol
    ../../../../SPI_Protocol_Common/: spi_config.h spi_protocol.c spi_protocol.h spi_protocol_common_actions.h spi_protocol_dfu_cmd.c spi_protocol_dfu_cmd.h spi_protocol_get_protocol_version.c spi_protocol_get_protocol_version.h spi_protocol_tx.c spi_protocol_tx.h
    ../../../src/SPI_Protocol/: spi_protocol_app_actions.h spi_protocol_ble_event.c spi_protocol_ble_event.h spi_protocol_ble_hid_advertising.c spi_protocol_ble_hid_advertising.h spi_protocol_ble_hid_hibernation.c spi_protocol_ble_hid_hibernation.h spi_protocol_ble_hid_input_report.c spi_protocol_ble_hid_input_report.h spi_protocol_ble_hid_output_report.c spi_protocol_ble_hid_output_report.h spi_protocol_ble_hid_peer_management.c spi_protocol_ble_hid_peer_management.h spi_protocol_ble_hid_radio_power.c spi_protocol_ble_hid_radio_power.h spi_protocol_ble_hid_report_map.c spi_protocol_ble_hid_report_map.h spi_protocol_factory_reset.c spi_protocol_factory_reset.h spi_protocol_get_device_list.c spi_protocol_get_device_list.h spi_protocol_get_fw_version.c spi_protocol_get_fw_version.h spi_protocol_numeric_comparison.c spi_protocol_numeric_comparison.h spi_protocol_pairing_abort.c spi_protocol_pairing_abort.h spi_protocol_serial_data.c spi_protocol_serial_data.h
  group Board Definition
    ../../../../nRF5_SDK/components/boards/: boards.c
  group Board Support
    ../../../../nRF5_SDK/components/libraries/bsp/: bsp.c bsp_btn_ble.c
  group Device
    ../../../../nRF5_SDK/modules/nrfx/mdk/: iar_startup_nrf52.s system_nrf52.c
  group nRF_BLE
    ../../../../nRF5_SDK/components/ble/peer_manager/: auth_status_tracker.c gatt_cache_manager.c gatts_cache_manager.c id_manager.c nrf_ble_lesc.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c peer_manager_handler.c pm_buffer.c security_dispatcher.c security_manager.c
    ../../../../nRF5_SDK/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c
    ../../../../nRF5_SDK/components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
    ../../../../nRF5_SDK/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../../../../nRF5_SDK/components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
  group nRF_BLE_Services
    ../../../../nRF5_SDK/components/ble/ble_services/ble_dis/: ble_dis.c
    ../../../../nRF5_SDK/components/ble/ble_services/ble_hids/: ble_hids.c
  group nRF_Crypto
    ../../../../nRF5_SDK/components/libraries/crypto/: nrf_crypto_ecc.c nrf_crypto_ecdh.c nrf_crypto_init.c nrf_crypto_rng.c
  group nRF_Crypto backend nRF HW
    ../../../../nRF5_SDK/components/libraries/crypto/backend/nrf_hw/: nrf_hw_backend_init.c nrf_hw_backend_rng.c nrf_hw_backend_rng_mbedtls.c
  group nRF_Crypto backend Oberon
    ../../../../nRF5_SDK/components/libraries/crypto/backend/oberon/: oberon_backend_ecc.c oberon_backend_ecdh.c
  group nRF_Drivers
    ../../../../nRF5_SDK/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_rng.c nrf_drv_spis.c nrf_drv_uart.c
    ../../../../nRF5_SDK/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_rng.c nrfx_spis.c nrfx_uart.c nrfx_uarte.c
    ../../../../nRF5_SDK/modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../../../../nRF5_SDK/components/libraries/button/: app_button.c
    ../../../../nRF5_SDK/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_mapped_flags.c
    ../../../../nRF5_SDK/components/libraries/fifo/: app_fifo.c
    ../../../../nRF5_SDK/components/libraries/scheduler/: app_scheduler.c
    ../../../../nRF5_SDK/components/libraries/timer/: app_timer.c
    ../../../../nRF5_SDK/components/libraries/crc16/: crc16.c
    ../../../../nRF5_SDK/components/libraries/fds/: fds.c
    ../../../../nRF5_SDK/components/libraries/hardfault/: hardfault_implementation.c
    ../../../../nRF5_SDK/components/libraries/mem_manager/: mem_manager.c
    ../../../../nRF5_SDK/components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../nRF5_SDK/components/libraries/atomic_flags/: nrf_atflags.c
    ../../../../nRF5_SDK/components/libraries/atomic/: nrf_atomic.c
    ../../../../nRF5_SDK/components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../../../../nRF5_SDK/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../../nRF5_SDK/components/libraries/queue/: nrf_queue.c
    ../../../../nRF5_SDK/components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../nRF5_SDK/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../nRF5_SDK/components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../../../../nRF5_SDK/components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Oberon_Crypto
    ../../../../nRF5_SDK/external/nrf_oberon/lib/cortex-m4/hard-float/short-wchar/: liboberon_2.0.7.a
  group nRF_Segger_RTT
    ../../../../nRF5_SDK/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_IAR.c
  group nRF_SoftDevice
    ../../../../nRF5_SDK/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group nRF_TLS
    ../../../../nRF5_SDK/external/mbedtls/library/: aes.c ctr_drbg.c
