# IAR project ble_app_hrs_pca10040_s132.ewp, settings and files
configuration nrf52832_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: BLE_STACK_SUPPORT_REQD; BOARD_PCA10040; CONFIG_GPIO_AS_PINRESET; FLOAT_ABI_HARD; MBEDTLS_CONFIG_FILE=<nrf_crypto_mbedtls_config.h>; NRF52; NRF52832_XXAA; NRF52_PAN_74; NRF_CRYPTO_MAX_INSTANCE_COUNT=1; NRF_SD_BLE_API_VERSION=6; S132; SOFTDEVICE_PRESENT; SWI_DISABLE0; uECC_ENABLE_VLI_API=0; uECC_OPTIMIZATION_LEVEL=3; uECC_SQUARE_FUNC=0; uECC_SUPPORT_COMPRESSED_POINT=0; uECC_VLI_NATIVE_LITTLE_ENDIAN=1
  ICCARM.CCIncludePath2: $..\..\..\config; ..\..\..\..\nRF5_SDK\components; ..\..\..\..\nRF5_SDK\components\ble\ble_advertising; ..\..\..\..\nRF5_SDK\components\ble\ble_dtm; ..\..\..\..\nRF5_SDK\components\ble\ble_racp; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_ancs_c; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_ans_c; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_bas; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_bas_c; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_cscs; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_cts_c; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_dfu; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_dis; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_gls; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_hids; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_hrs; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_hrs_c; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_hts; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_ias; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_ias_c; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_lbs; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_lbs_c; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_lls; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_nus; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_nus_c; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_rscs; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_rscs_c; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_tps; ..\..\..\..\nRF5_SDK\components\ble\common; ..\..\..\..\nRF5_SDK\components\ble\nrf_ble_gatt; ..\..\..\..\nRF5_SDK\components\ble\nrf_ble_qwr; ..\..\..\..\nRF5_SDK\components\ble\peer_manager; ..\..\..\..\nRF5_SDK\components\boards; ..\..\..\..\nRF5_SDK\components\drivers_nrf\usbd; ..\..\..\..\nRF5_SDK\components\libraries\atomic; ..\..\..\..\nRF5_SDK\components\libraries\atomic_fifo; ..\..\..\..\nRF5_SDK\components\libraries\atomic_flags; ..\..\..\..\nRF5_SDK\components\libraries\balloc; ..\..\..\..\nRF5_SDK\components\libraries\bootloader\ble_dfu; ..\..\..\..\nRF5_SDK\components\libraries\bsp; ..\..\..\..\nRF5_SDK\components\libraries\button; ..\..\..\..\nRF5_SDK\components\libraries\cli; ..\..\..\..\nRF5_SDK\components\libraries\crc16; ..\..\..\..\nRF5_SDK\components\libraries\crc32; ..\..\..\..\nRF5_SDK\components\libraries\crypto; ..\..\..\..\nRF5_SDK\components\libraries\crypto\backend\cc310; ..\..\..\..\nRF5_SDK\components\libraries\crypto\backend\cc310_bl; ..\..\..\..\nRF5_SDK\components\libraries\crypto\backend\cifra; ..\..\..\..\nRF5_SDK\components\libraries\crypto\backend\mbedtls; ..\..\..\..\nRF5_SDK\components\libraries\crypto\backend\micro_ecc; ..\..\..\..\nRF5_SDK\components\libraries\crypto\backend\nrf_hw; ..\..\..\..\nRF5_SDK\components\libraries\crypto\backend\nrf_sw; ..\..\..\..\nRF5_SDK\components\libraries\crypto\backend\oberon; ..\..\..\..\nRF5_SDK\components\libraries\csense; ..\..\..\..\nRF5_SDK\components\libraries\csense_drv; ..\..\..\..\nRF5_SDK\components\libraries\delay; ..\..\..\..\nRF5_SDK\components\libraries\ecc; ..\..\..\..\nRF5_SDK\components\libraries\experimental_section_vars; ..\..\..\..\nRF5_SDK\components\libraries\experimental_task_manager; ..\..\..\..\nRF5_SDK\components\libraries\fds; ..\..\..\..\nRF5_SDK\components\libraries\fstorage; ..\..\..\..\nRF5_SDK\components\libraries\gfx; ..\..\..\..\nRF5_SDK\components\libraries\gpiote; ..\..\..\..\nRF5_SDK\components\libraries\hardfault; ..\..\..\..\nRF5_SDK\components\libraries\hci; ..\..\..\..\nRF5_SDK\components\libraries\led_softblink; ..\..\..\..\nRF5_SDK\components\libraries\log; ..\..\..\..\nRF5_SDK\components\libraries\log\src; ..\..\..\..\nRF5_SDK\components\libraries\low_power_pwm; ..\..\..\..\nRF5_SDK\components\libraries\mem_manager; ..\..\..\..\nRF5_SDK\components\libraries\memobj; ..\..\..\..\nRF5_SDK\components\libraries\mpu; ..\..\..\..\nRF5_SDK\components\libraries\mutex; ..\..\..\..\nRF5_SDK\components\libraries\pwm; ..\..\..\..\nRF5_SDK\components\libraries\pwr_mgmt; ..\..\..\..\nRF5_SDK\components\libraries\queue; ..\..\..\..\nRF5_SDK\components\libraries\ringbuf; ..\..\..\..\nRF5_SDK\components\libraries\scheduler; ..\..\..\..\nRF5_SDK\components\libraries\sdcard; ..\..\..\..\nRF5_SDK\components\libraries\sensorsim; ..\..\..\..\nRF5_SDK\components\libraries\slip; ..\..\..\..\nRF5_SDK\components\libraries\sortlist; ..\..\..\..\nRF5_SDK\components\libraries\spi_mngr; ..\..\..\..\nRF5_SDK\components\libraries\stack_guard; ..\..\..\..\nRF5_SDK\components\libraries\stack_info; ..\..\..\..\nRF5_SDK\components\libraries\strerror; ..\..\..\..\nRF5_SDK\components\libraries\svc; ..\..\..\..\nRF5_SDK\components\libraries\timer; ..\..\..\..\nRF5_SDK\components\libraries\twi_mngr; ..\..\..\..\nRF5_SDK\components\libraries\twi_sensor; ..\..\..\..\nRF5_SDK\components\libraries\usbd; ..\..\..\..\nRF5_SDK\components\libraries\usbd\class\audio; ..\..\..\..\nRF5_SDK\components\libraries\usbd\class\cdc; ..\..\..\..\nRF5_SDK\components\libraries\usbd\class\cdc\acm; ..\..\..\..\nRF5_SDK\components\libraries\usbd\class\hid; ..\..\..\..\nRF5_SDK\components\libraries\usbd\class\hid\generic; ..\..\..\..\nRF5_SDK\components\libraries\usbd\class\hid\kbd; ..\..\..\..\nRF5_SDK\components\libraries\usbd\class\hid\mouse; ..\..\..\..\nRF5_SDK\components\libraries\usbd\class\msc; ..\..\..\..\nRF5_SDK\components\libraries\util; ..\..\..\..\nRF5_SDK\components\nfc\ndef\conn_hand_parser; ..\..\..\..\nRF5_SDK\components\nfc\ndef\conn_hand_parser\ac_rec_parser; ..\..\..\..\nRF5_SDK\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser; ..\..\..\..\nRF5_SDK\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser; ..\..\..\..\nRF5_SDK\components\nfc\ndef\connection_handover\ac_rec; ..\..\..\..\nRF5_SDK\components\nfc\ndef\connection_handover\ble_oob_advdata; ..\..\..\..\nRF5_SDK\components\nfc\ndef\connection_handover\ble_pair_lib; ..\..\..\..\nRF5_SDK\components\nfc\ndef\connection_handover\ble_pair_msg; ..\..\..\..\nRF5_SDK\components\nfc\ndef\connection_handover\common; ..\..\..\..\nRF5_SDK\components\nfc\ndef\connection_handover\ep_oob_rec; ..\..\..\..\nRF5_SDK\components\nfc\ndef\connection_handover\hs_rec; ..\..\..\..\nRF5_SDK\components\nfc\ndef\connection_handover\le_oob_rec; ..\..\..\..\nRF5_SDK\components\nfc\ndef\generic\message; ..\..\..\..\nRF5_SDK\components\nfc\ndef\generic\record; ..\..\..\..\nRF5_SDK\components\nfc\ndef\launchapp; ..\..\..\..\nRF5_SDK\components\nfc\ndef\parser\message; ..\..\..\..\nRF5_SDK\components\nfc\ndef\parser\record; ..\..\..\..\nRF5_SDK\components\nfc\ndef\text; ..\..\..\..\nRF5_SDK\components\nfc\ndef\uri; ..\..\..\..\nRF5_SDK\components\nfc\t2t_lib; ..\..\..\..\nRF5_SDK\components\nfc\t2t_lib\hal_t2t; ..\..\..\..\nRF5_SDK\components\nfc\t2t_parser; ..\..\..\..\nRF5_SDK\components\nfc\t4t_lib; ..\..\..\..\nRF5_SDK\components\nfc\t4t_lib\hal_t4t; ..\..\..\..\nRF5_SDK\components\nfc\t4t_parser\apdu; ..\..\..\..\nRF5_SDK\components\nfc\t4t_parser\cc_file; ..\..\..\..\nRF5_SDK\components\nfc\t4t_parser\hl_detection_procedure; ..\..\..\..\nRF5_SDK\components\nfc\t4t_parser\tlv; ..\..\..\..\nRF5_SDK\components\softdevice\common; ..\..\..\..\nRF5_SDK\components\softdevice\s132\headers; ..\..\..\..\nRF5_SDK\components\softdevice\s132\headers\nrf52; ..\..\..\..\nRF5_SDK\components\toolchain\cmsis\include; ..\..\..\..\nRF5_SDK\external\fprintf; ..\..\..\..\nRF5_SDK\external\mbedtls\include; ..\..\..\..\nRF5_SDK\external\micro-ecc\micro-ecc; ..\..\..\..\nRF5_SDK\external\nrf_cc310\include; ..\..\..\..\nRF5_SDK\external\nrf_oberon; ..\..\..\..\nRF5_SDK\external\nrf_oberon\include; ..\..\..\..\nRF5_SDK\external\nrf_tls\mbedtls\nrf_crypto\config; ..\..\..\..\nRF5_SDK\external\segger_rtt; ..\..\..\..\nRF5_SDK\external\utf_converter; ..\..\..\..\nRF5_SDK\integration\nrfx; ..\..\..\..\nRF5_SDK\integration\nrfx\legacy; ..\..\..\..\nRF5_SDK\modules\nrfx; ..\..\..\..\nRF5_SDK\modules\nrfx\drivers\include; ..\..\..\..\nRF5_SDK\modules\nrfx\hal; ..\..\..\..\nRF5_SDK\modules\nrfx\mdk; ..\config; ..\..\..\..\nRF5_SDK\components\ble\ble_link_ctx_manager
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: ..\..\..\config; ..\..\..\..\nRF5_SDK\components; ..\..\..\..\nRF5_SDK\components\ble\ble_advertising; ..\..\..\..\nRF5_SDK\components\ble\ble_dtm; ..\..\..\..\nRF5_SDK\components\ble\ble_racp; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_ancs_c; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_ans_c; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_bas; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_bas_c; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_cscs; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_cts_c; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_dfu; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_dis; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_gls; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_hids; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_hrs; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_hrs_c; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_hts; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_ias; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_ias_c; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_lbs; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_lbs_c; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_lls; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_nus; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_nus_c; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_rscs; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_rscs_c; ..\..\..\..\nRF5_SDK\components\ble\ble_services\ble_tps; ..\..\..\..\nRF5_SDK\components\ble\common; ..\..\..\..\nRF5_SDK\components\ble\nrf_ble_gatt; ..\..\..\..\nRF5_SDK\components\ble\nrf_ble_qwr; ..\..\..\..\nRF5_SDK\components\ble\peer_manager; ..\..\..\..\nRF5_SDK\components\boards; ..\..\..\..\nRF5_SDK\components\drivers_nrf\usbd; ..\..\..\..\nRF5_SDK\components\libraries\atomic; ..\..\..\..\nRF5_SDK\components\libraries\atomic_fifo; ..\..\..\..\nRF5_SDK\components\libraries\atomic_flags; ..\..\..\..\nRF5_SDK\components\libraries\balloc; ..\..\..\..\nRF5_SDK\components\libraries\bootloader\ble_dfu; ..\..\..\..\nRF5_SDK\components\libraries\bsp; ..\..\..\..\nRF5_SDK\components\libraries\button; ..\..\..\..\nRF5_SDK\components\libraries\cli; ..\..\..\..\nRF5_SDK\components\libraries\crc16; ..\..\..\..\nRF5_SDK\components\libraries\crc32; ..\..\..\..\nRF5_SDK\components\libraries\crypto; ..\..\..\..\nRF5_SDK\components\libraries\crypto\backend\cc310; ..\..\..\..\nRF5_SDK\components\libraries\crypto\backend\cc310_bl; ..\..\..\..\nRF5_SDK\components\libraries\crypto\backend\cifra; ..\..\..\..\nRF5_SDK\components\libraries\crypto\backend\mbedtls; ..\..\..\..\nRF5_SDK\components\libraries\crypto\backend\micro_ecc; ..\..\..\..\nRF5_SDK\components\libraries\crypto\backend\nrf_hw; ..\..\..\..\nRF5_SDK\components\libraries\crypto\backend\nrf_sw; ..\..\..\..\nRF5_SDK\components\libraries\crypto\backend\oberon; ..\..\..\..\nRF5_SDK\components\libraries\csense; ..\..\..\..\nRF5_SDK\components\libraries\csense_drv; ..\..\..\..\nRF5_SDK\components\libraries\delay; ..\..\..\..\nRF5_SDK\components\libraries\ecc; ..\..\..\..\nRF5_SDK\components\libraries\experimental_section_vars; ..\..\..\..\nRF5_SDK\components\libraries\experimental_task_manager; ..\..\..\..\nRF5_SDK\components\libraries\fds; ..\..\..\..\nRF5_SDK\components\libraries\fstorage; ..\..\..\..\nRF5_SDK\components\libraries\gfx; ..\..\..\..\nRF5_SDK\components\libraries\gpiote; ..\..\..\..\nRF5_SDK\components\libraries\hardfault; ..\..\..\..\nRF5_SDK\components\libraries\hci; ..\..\..\..\nRF5_SDK\components\libraries\led_softblink; ..\..\..\..\nRF5_SDK\components\libraries\log; ..\..\..\..\nRF5_SDK\components\libraries\log\src; ..\..\..\..\nRF5_SDK\components\libraries\low_power_pwm; ..\..\..\..\nRF5_SDK\components\libraries\mem_manager; ..\..\..\..\nRF5_SDK\components\libraries\memobj; ..\..\..\..\nRF5_SDK\components\libraries\mpu; ..\..\..\..\nRF5_SDK\components\libraries\mutex; ..\..\..\..\nRF5_SDK\components\libraries\pwm; ..\..\..\..\nRF5_SDK\components\libraries\pwr_mgmt; ..\..\..\..\nRF5_SDK\components\libraries\queue; ..\..\..\..\nRF5_SDK\components\libraries\ringbuf; ..\..\..\..\nRF5_SDK\components\libraries\scheduler; ..\..\..\..\nRF5_SDK\components\libraries\sdcard; ..\..\..\..\nRF5_SDK\components\libraries\sensorsim; ..\..\..\..\nRF5_SDK\components\libraries\slip; ..\..\..\..\nRF5_SDK\components\libraries\sortlist; ..\..\..\..\nRF5_SDK\components\libraries\spi_mngr; ..\..\..\..\nRF5_SDK\components\libraries\stack_guard; ..\..\..\..\nRF5_SDK\components\libraries\stack_info; ..\..\..\..\nRF5_SDK\components\libraries\strerror; ..\..\..\..\nRF5_SDK\components\libraries\svc; ..\..\..\..\nRF5_SDK\components\libraries\timer; ..\..\..\..\nRF5_SDK\components\libraries\twi_mngr; ..\..\..\..\nRF5_SDK\components\libraries\twi_sensor; ..\..\..\..\nRF5_SDK\components\libraries\usbd; ..\..\..\..\nRF5_SDK\components\libraries\usbd\class\audio; ..\..\..\..\nRF5_SDK\components\libraries\usbd\class\cdc; ..\..\..\..\nRF5_SDK\components\libraries\usbd\class\cdc\acm; ..\..\..\..\nRF5_SDK\components\libraries\usbd\class\hid; ..\..\..\..\nRF5_SDK\components\libraries\usbd\class\hid\generic; ..\..\..\..\nRF5_SDK\components\libraries\usbd\class\hid\kbd; ..\..\..\..\nRF5_SDK\components\libraries\usbd\class\hid\mouse; ..\..\..\..\nRF5_SDK\components\libraries\usbd\class\msc; ..\..\..\..\nRF5_SDK\components\libraries\util; ..\..\..\..\nRF5_SDK\components\nfc\ndef\conn_hand_parser; ..\..\..\..\nRF5_SDK\components\nfc\ndef\conn_hand_parser\ac_rec_parser; ..\..\..\..\nRF5_SDK\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser; ..\..\..\..\nRF5_SDK\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser; ..\..\..\..\nRF5_SDK\components\nfc\ndef\connection_handover\ac_rec; ..\..\..\..\nRF5_SDK\components\nfc\ndef\connection_handover\ble_oob_advdata; ..\..\..\..\nRF5_SDK\components\nfc\ndef\connection_handover\ble_pair_lib; ..\..\..\..\nRF5_SDK\components\nfc\ndef\connection_handover\ble_pair_msg; ..\..\..\..\nRF5_SDK\components\nfc\ndef\connection_handover\common; ..\..\..\..\nRF5_SDK\components\nfc\ndef\connection_handover\ep_oob_rec; ..\..\..\..\nRF5_SDK\components\nfc\ndef\connection_handover\hs_rec; ..\..\..\..\nRF5_SDK\components\nfc\ndef\connection_handover\le_oob_rec; ..\..\..\..\nRF5_SDK\components\nfc\ndef\generic\message; ..\..\..\..\nRF5_SDK\components\nfc\ndef\generic\record; ..\..\..\..\nRF5_SDK\components\nfc\ndef\launchapp; ..\..\..\..\nRF5_SDK\components\nfc\ndef\parser\message; ..\..\..\..\nRF5_SDK\components\nfc\ndef\parser\record; ..\..\..\..\nRF5_SDK\components\nfc\ndef\text; ..\..\..\..\nRF5_SDK\components\nfc\ndef\uri; ..\..\..\..\nRF5_SDK\components\nfc\t2t_lib; ..\..\..\..\nRF5_SDK\components\nfc\t2t_lib\hal_t2t; ..\..\..\..\nRF5_SDK\components\nfc\t2t_parser; ..\..\..\..\nRF5_SDK\components\nfc\t4t_lib; ..\..\..\..\nRF5_SDK\components\nfc\t4t_lib\hal_t4t; ..\..\..\..\nRF5_SDK\components\nfc\t4t_parser\apdu; ..\..\..\..\nRF5_SDK\components\nfc\t4t_parser\cc_file; ..\..\..\..\nRF5_SDK\components\nfc\t4t_parser\hl_detection_procedure; ..\..\..\..\nRF5_SDK\components\nfc\t4t_parser\tlv; ..\..\..\..\nRF5_SDK\components\softdevice\common; ..\..\..\..\nRF5_SDK\components\softdevice\s132\headers; ..\..\..\..\nRF5_SDK\components\softdevice\s132\headers\nrf52; ..\..\..\..\nRF5_SDK\components\toolchain\cmsis\include; ..\..\..\..\nRF5_SDK\external\fprintf; ..\..\..\..\nRF5_SDK\external\mbedtls\include; ..\..\..\..\nRF5_SDK\external\micro-ecc\micro-ecc; ..\..\..\..\nRF5_SDK\external\nrf_cc310\include; ..\..\..\..\nRF5_SDK\external\nrf_oberon; ..\..\..\..\nRF5_SDK\external\nrf_oberon\include; ..\..\..\..\nRF5_SDK\external\nrf_tls\mbedtls\nrf_crypto\config; ..\..\..\..\nRF5_SDK\external\segger_rtt; ..\..\..\..\nRF5_SDK\external\utf_converter; ..\..\..\..\nRF5_SDK\integration\nrfx; ..\..\..\..\nRF5_SDK\integration\nrfx\legacy; ..\..\..\..\nRF5_SDK\modules\nrfx; ..\..\..\..\nRF5_SDK\modules\nrfx\drivers\include; ..\..\..\..\nRF5_SDK\modules\nrfx\hal; ..\..\..\..\nRF5_SDK\modules\nrfx\mdk; ..\config
  OBJCOPY.OOCOutputFile: ble_app_hrs_pca10040_s132.hex
  ILINK.IlinkOutputFile: ble_app_hrs_pca10040_s132.out
  ILINK.IlinkIcfFile: ble_app_hrs_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../nRF5_SDK/components/boards/: boards.c
  group Board Support
    ../../../../nRF5_SDK/components/libraries/bsp/: bsp.c bsp_btn_ble.c
  group None
    ../../../../nRF5_SDK/modules/nrfx/mdk/: iar_startup_nrf52.s system_nrf52.c
  group nRF_BLE
    ../../../../nRF5_SDK/components/ble/peer_manager/: auth_status_tracker.c gatt_cache_manager.c gatts_cache_manager.c id_manager.c nrf_ble_lesc.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c peer_manager_handler.c pm_buffer.c security_dispatcher.c security_manager.c
    ../../../../nRF5_SDK/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../../nRF5_SDK/components/ble/ble_advertising/: ble_advertising.c
    ../../../../nRF5_SDK/components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
    ../../../../nRF5_SDK/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../../../../nRF5_SDK/components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
  group nRF_BLE_Services
    ../../../../nRF5_SDK/components/ble/ble_services/ble_bas/: ble_bas.c
    ../../../../nRF5_SDK/components/ble/ble_services/ble_dis/: ble_dis.c
    ../../../../nRF5_SDK/components/ble/ble_services/ble_hrs/: ble_hrs.c
    ../../../../nRF5_SDK/components/ble/ble_services/ble_nus/: ble_nus.c
  group nrf_cc310
    ../../../../nRF5_SDK/external/nrf_cc310/lib/: libnrf_cc310_short_wchar_0.9.10.a
  group nRF_Crypto
    ../../../../nRF5_SDK/components/libraries/crypto/: nrf_crypto_aead.c nrf_crypto_aes.c nrf_crypto_aes_shared.c nrf_crypto_ecc.c nrf_crypto_ecdh.c nrf_crypto_ecdsa.c nrf_crypto_eddsa.c nrf_crypto_error.c nrf_crypto_hash.c nrf_crypto_hkdf.c nrf_crypto_hmac.c nrf_crypto_init.c nrf_crypto_rng.c nrf_crypto_shared.c
  group nRF_Crypto backend nRF HW
    ../../../../nRF5_SDK/components/libraries/crypto/backend/nrf_hw/: nrf_hw_backend_init.c nrf_hw_backend_rng.c nrf_hw_backend_rng_mbedtls.c
  group nRF_Crypto backend Oberon
    ../../../../nRF5_SDK/components/libraries/crypto/backend/oberon/: oberon_backend_chacha_poly_aead.c oberon_backend_ecc.c oberon_backend_ecdh.c oberon_backend_ecdsa.c oberon_backend_eddsa.c oberon_backend_hash.c oberon_backend_hmac.c
  group nRF_Crypto backend uECC
    ../../../../nRF5_SDK/components/libraries/crypto/backend/micro_ecc/: micro_ecc_backend_ecc.c micro_ecc_backend_ecdh.c micro_ecc_backend_ecdsa.c
  group nRF_Drivers
    ../../../../nRF5_SDK/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_rng.c nrf_drv_uart.c
    ../../../../nRF5_SDK/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_power_clock.c nrfx_rng.c nrfx_uart.c nrfx_uarte.c
    ../../../../nRF5_SDK/modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../../../../nRF5_SDK/components/libraries/button/: app_button.c
    ../../../../nRF5_SDK/components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../nRF5_SDK/components/libraries/scheduler/: app_scheduler.c
    ../../../../nRF5_SDK/components/libraries/timer/: app_timer.c
    ../../../../nRF5_SDK/components/libraries/crc16/: crc16.c
    ../../../../nRF5_SDK/components/libraries/fds/: fds.c
    ../../../../nRF5_SDK/components/libraries/hardfault/: hardfault_implementation.c
    ../../../../nRF5_SDK/components/libraries/mem_manager/: mem_manager.c
    ../../../../nRF5_SDK/components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../nRF5_SDK/components/libraries/atomic_flags/: nrf_atflags.c
    ../../../../nRF5_SDK/components/libraries/atomic/: nrf_atomic.c
    ../../../../nRF5_SDK/components/libraries/balloc/: nrf_balloc.c
    ../../../../nRF5_SDK/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../nRF5_SDK/components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../../../../nRF5_SDK/components/libraries/memobj/: nrf_memobj.c
    ../../../../nRF5_SDK/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../../nRF5_SDK/components/libraries/queue/: nrf_queue.c
    ../../../../nRF5_SDK/components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../nRF5_SDK/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../nRF5_SDK/components/libraries/strerror/: nrf_strerror.c
    ../../../../nRF5_SDK/components/libraries/sensorsim/: sensorsim.c
  group nRF_Log
    ../../../../nRF5_SDK/components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Oberon_Crypto
    ../../../../nRF5_SDK/external/nrf_oberon/lib/nrf52/: liboberon_short_wchar_2.0.5.a
  group nRF_Segger_RTT
    ../../../../nRF5_SDK/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_IAR.c
  group nRF_SoftDevice
    ../../../../nRF5_SDK/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group nRF_TLS
    ../../../../nRF5_SDK/external/mbedtls/library/: aes.c ctr_drbg.c
  group UTF8/UTF16 converter
    ../../../../nRF5_SDK/external/utf_converter/: utf.c
